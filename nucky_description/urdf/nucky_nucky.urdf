Commit message: Major Update

File: nucky_description/urdf/nucky_nucky.urdf (robot description, URDF)
Before this commit: robot Nucky, 9 links, 8 joints
Joints:
- joint chassis_to_realcammount: origin xyz=0.6 0 0 rpy=0 0 0 -> xyz=0 0 0.4 rpy=0 0 0
